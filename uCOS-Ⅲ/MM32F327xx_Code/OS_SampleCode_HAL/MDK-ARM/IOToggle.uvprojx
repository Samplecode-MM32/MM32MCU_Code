# Keil uVision project IOToggle.uvprojx, settings and files
target MM32Series (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MM32F103CET MindMotion
  pack: MindMotion.MM32F103xCxE_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MM32 +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\UCOSIII\uC-CPU;..\UCOSIII\uC-CPU\ARM-Cortex-M3\RealView;..\UCOSIII\uC-LIB;..\UCOSIII\uC-LIB\Ports\ARM-Cortex-M3\RealView;..\UCOSIII\uCOS-III;..\UCOSIII\uCOS-III\Ports\ARM-Cortex-M3\Generic\RealView;..\UCOSIII\UCOS_BSP;..\UCOSIII\uCOS_CONFIG;..\UCOSIII\uCOS-III\Source;..\UCOSIII_Task;..\..\Device\CMSIS\KEIL_Core;..\..\Device\MM32F327x\HAL_Lib\Inc;..\..\Device\MM32F327x\Include;..\APP\inc;..\BSP\inc;..\Peripheral\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../../Device/MM32F327x/Source/: system_mm32f327x.c
    ../../Device/MM32F327x/Source/KEIL_StartAsm/: startup_mm32f327x_keil.s
  group Peripheral
    ../Peripheral/src/: delay.c sys.c uart.c
  group APP
    ../APP/src/: main.c
  group HAL_Lib
    ../../Device/MM32F327x/HAL_Lib/Src/: hal_adc.c hal_bkp.c hal_can.c hal_comp.c hal_crc.c hal_crs.c hal_dac.c hal_dbg.c hal_dma.c hal_eth.c hal_exti.c hal_flash.c hal_fsmc.c hal_gpio.c hal_i2c.c hal_iwdg.c hal_misc.c hal_pwr.c hal_rcc.c hal_rtc.c hal_sdio.c hal_spi.c hal_tim.c hal_uart.c hal_uid.c hal_ver.c hal_wwdg.c
  group UCOSⅢ_BSP
    ../UCOSIII/UCOS_BSP/: bsp.c
  group UCOSⅢ_CPU
    ../UCOSIII/uC-CPU/: cpu_core.c
    ../UCOSIII/uC-CPU/ARM-Cortex-M3/IAR/: cpu_c.c
    ../UCOSIII/uC-CPU/ARM-Cortex-M3/RealView/: cpu_a.asm
  group UCOSⅢ_LIB
    ../UCOSIII/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../UCOSIII/uC-LIB/Ports/ARM-Cortex-M3/RealView/: lib_mem_a.asm
  group UCOSⅢ_CORE
    ../UCOSIII/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group UCOSⅢ_PORT
    ../UCOSIII/uCOS-III/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu_c.c os_cpu_a.s
  group UCOSⅢ_COMFIG
    ../UCOSIII/uCOS_CONFIG/: os_app_hooks.c
  group UCOSⅢ_Task
    ../UCOSIII_Task/: led_task.c start_task.c Hekr_Protocol.c
