# Keil uVision project GPIO_Toggle.uvprojx, settings and files
target MM32Series (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MM32F0133C7P MindMotion
  pack: MindMotion.MM32F0130_DFP.1.0.2
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: MBOUT +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\RTT\cortex-m0;..\RTT\include;..\RTT\drivers;..\..\Device\CMSIS\KEIL_Core;..\..\Device\MM32F013x\HAL_Lib\Inc;..\..\Device\MM32F013x\Include;..\APP\inc;..\BSP\inc;..\Peripheral\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group STARTUP
    ../../Device/MM32F013x/Source/: system_mm32f013x.c
    ../../Device/MM32F013x/Source/KEIL_StartAsm/: startup_mm32f013x_keil.s
  group BSP
    ../BSP/: led.c
  group Peripheral
    ../Peripheral/: delay.c sys.c uart.c
  group APP
    ../APP/: main.c
  group HAL_Lib
    ../../Device/MM32F013x/HAL_Lib/Src/: hal_adc.c hal_bkp.c hal_can.c hal_comp.c hal_crc.c hal_crs.c hal_dbg.c hal_div.c hal_dma.c hal_exti.c hal_flash.c hal_gpio.c hal_i2c.c hal_iwdg.c hal_misc.c hal_pwr.c hal_rcc.c hal_rtc.c hal_spi.c hal_tim.c hal_uart.c hal_uid.c hal_ver.c hal_wwdg.c
  group RTTOS/src
    ../RTT/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c slab.c thread.c timer.c
  group RTTOS/cpu
    ../RTT/common/: div0.c backtrace.c
    ../RTT/cortex-m0/: context_rvds.S cpuport.c
    ../RTT/drivers/: board.c
