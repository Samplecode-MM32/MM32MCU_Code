# Keil uVision project GPIO_LED.uvprojx, settings and files
target MM32Series (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MM32F032R8T6 MindMotion
  pack: MindMotion.MM32F032_DFP.1.0.2
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: GPIO_LED +hex
  AfterMake: fromelf --bin "$L@L.axf" --output "$L@L.bin"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\Peripheral\inc;..\BSP\inc;..\APP\inc;..\ONEOS\arch\arm\cortex-m0;..\ONEOS\common\include;..\ONEOS\kernel\include;..\ONEOS\kernel\source\extend;..\ONEOS\kernel\include\extend;..\..\Device\CMSIS\KEIL_Core;..\..\Device\MM32F013x\HAL_Lib\Inc;..\..\Device\MM32F013x\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group STARTUP
    ../../Device/MM32F013x/Source/: system_mm32f013x.c
    ../../Device/MM32F013x/Source/KEIL_StartAsm/: startup_mm32f013x_keil.s
  group BSP
    ../BSP/: bsp_led.c
  group Peripheral
    ../Peripheral/: systick.c uart.c
  group APP
    ../APP/: main.c drv_common.c
  group HAL_Lib
    ../../Device/MM32F013x/HAL_Lib/Src/: hal_adc.c hal_bkp.c hal_can.c hal_comp.c hal_crc.c hal_crs.c hal_dbg.c hal_div.c hal_dma.c hal_exti.c hal_flash.c hal_gpio.c hal_i2c.c hal_iwdg.c hal_misc.c hal_pwr.c hal_rcc.c hal_rtc.c hal_spi.c hal_tim.c hal_uart.c hal_uid.c hal_ver.c hal_wwdg.c
  group Common
    ../ONEOS/common/source/: option_parse.c ring_blk_buff.c ring_buff.c
  group os/kernel
    ../ONEOS/kernel/source/: os_clock.c os_device.c os_event.c os_idle.c os_ipc.c os_irq.c os_kernel_log.c os_mailbox.c os_mem_heap.c os_mem_pool.c os_mem_slab.c os_mem_small.c os_mq.c os_mutex.c os_object.c os_sem.c os_signal.c os_startup.c os_task.c os_timer.c os_util.c os_version.c
    ../ONEOS/kernel/source/extend/: os_completion.c os_dataqueue.c os_waitqueue.c os_workqueue.c
  group os/CPU
    ../ONEOS/arch/arm/cortex-m0/: context_rvds.S cpuport.c
