# Keil uVision project GPIO_Toggle.uvprojx, settings and files
target MM32Series (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MM32F0133C7P MindMotion
  pack: MindMotion.MM32F0130_DFP.1.0.2
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: MBOUT +hex
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER
  c include: ..\AliOS\utility\libc\compilers\armlibc;..\AliOS\kernel\vcall\aos;..\AliOS\kernel\rhino\core\include;..\AliOS\platform\arch\arm\armv6m\armcc\m0;..\APP\inc;..\BSP\inc;..\Peripheral\inc;..\..\Device\CMSIS\KEIL_CORE;..\..\Device\MM32F013x\HAL_Lib\Inc;..\..\Device\MM32F013x\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group STARTUP
    ../../Device/MM32F013x/Source/: system_mm32f013x.c
    ../../Device/MM32F013x/Source/KEIL_StartAsm/: startup_mm32f013x_keil.s
  group BSP
    ../BSP/: led.c
  group Peripheral
    ../Peripheral/: delay.c sys.c uart.c
  group APP
    ../APP/: main.c soc_impl.c
  group HAL_Lib
    ../../Device/MM32F013x/HAL_Lib/Src/: hal_adc.c hal_bkp.c hal_can.c hal_comp.c hal_crc.c hal_crs.c hal_dbg.c hal_div.c hal_dma.c hal_exti.c hal_flash.c hal_gpio.c hal_i2c.c hal_iwdg.c hal_misc.c hal_pwr.c hal_rcc.c hal_rtc.c hal_spi.c hal_tim.c hal_uart.c hal_uid.c hal_ver.c hal_wwdg.c
  group AliOS/rhino
    ../AliOS/kernel/rhino/core/: k_buf_queue.c k_dyn_mem_proc.c k_err.c k_event.c k_idle.c k_mm.c k_mm_blk.c k_mm_debug.c k_mutex.c k_obj.c k_pend.c k_queue.c k_ringbuf.c k_sched.c k_sem.c k_stats.c k_sys.c k_task.c k_task_sem.c k_tick.c k_time.c k_timer.c k_workqueue.c
  group AliOS/cpu
    ../AliOS/platform/arch/arm/armv6m/armcc/m0/: port_c.c port_s.S
  group AliOS/utility
    ../AliOS/utility/libc/compilers/armlibc/: armcc_libc.c
