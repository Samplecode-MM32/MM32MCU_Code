# Keil uVision project IOToggle.uvprojx, settings and files
target MM32Series (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MM32F3277G7P MindMotion
  pack: MindMotion.MM32F327x_DFP.1.0.1
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: output +hex
  c flags: Optim=1 uC99=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\AliOS\utility\libc\compilers\armlibc;..\AliOS\kernel\vcall\aos;..\AliOS\kernel\rhino\core\include;..\AliOS\platform\arch\arm\armv7m\armcc\m3;..\..\Device\CMSIS\KEIL_CORE;..\..\Device\MM32F327x\HAL_Lib\Inc;..\..\Device\MM32F327x\Include;..\APP\inc;..\Peripheral\inc;..\BSP\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group STARTUP
    ../../Device/MM32F327x/Source/: system_mm32f327x.c
    ../../Device/MM32F327x/Source/KEIL_StartAsm/: startup_mm32f327x_keil.s
  group BSP
    ../BSP/src/: led.c
  group Peripheral
    ../Peripheral/src/: delay.c sys.c uart.c
  group APP
    ../APP/src/: main.c soc_impl.c
  group HAL_Lib
    ../../Device/MM32F327x/HAL_Lib/Src/: hal_adc.c hal_bkp.c hal_can.c hal_comp.c hal_crc.c hal_crs.c hal_dac.c hal_dbg.c hal_dma.c hal_eth.c hal_exti.c hal_flash.c hal_fsmc.c hal_gpio.c hal_i2c.c hal_iwdg.c hal_misc.c hal_pwr.c hal_rcc.c hal_rtc.c hal_sdio.c hal_spi.c hal_tim.c hal_uart.c hal_uid.c hal_ver.c hal_wwdg.c
  group AliOS/rhino
    ../AliOS/kernel/rhino/core/: k_buf_queue.c k_dyn_mem_proc.c k_err.c k_event.c k_idle.c k_mm.c k_mm_blk.c k_mm_debug.c k_mutex.c k_obj.c k_pend.c k_queue.c k_ringbuf.c k_sched.c k_sem.c k_stats.c k_sys.c k_task.c k_task_sem.c k_tick.c k_time.c k_timer.c k_workqueue.c
  group AliOS/cpu
    ../AliOS/platform/arch/arm/armv7m/armcc/m3/: port_c.c port_s.s
  group AliOS/utility
    ../AliOS/utility/libc/compilers/armlibc/: armcc_libc.c
