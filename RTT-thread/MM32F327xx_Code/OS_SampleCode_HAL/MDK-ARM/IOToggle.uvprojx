# Keil uVision project IOToggle.uvprojx, settings and files
target MM32Series (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MM32L373PF MindMotion
  pack: MindMotion.MM32L3xx_DFP.1.0.7
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: output +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\RTT\cortex-m3;..\RTT\include;..\RTT\drivers;..\..\Device\CMSIS\KEIL_Core;..\..\Device\MM32F327x\HAL_Lib\Inc;..\..\Device\MM32F327x\Include;..\APP\inc;..\BSP\inc;..\Peripheral\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../../Device/MM32F327x/Source/: system_mm32f327x.c
    ../../Device/MM32F327x/Source/KEIL_StartAsm/: startup_mm32f327x_keil.s
  group BSP
    ../BSP/src/: led.c
  group Peripheral
    ../Peripheral/src/: delay.c sys.c uart.c
  group APP
    ../APP/src/: main.c
  group HA_Lib
    ../../Device/MM32F327x/HAL_Lib/Src/: hal_adc.c hal_bkp.c hal_can.c hal_comp.c hal_crc.c hal_crs.c hal_dac.c hal_dbg.c hal_dma.c hal_eth.c hal_exti.c hal_flash.c hal_fsmc.c hal_gpio.c hal_i2c.c hal_iwdg.c hal_misc.c hal_pwr.c hal_rcc.c hal_rtc.c hal_sdio.c hal_spi.c hal_tim.c hal_uart.c hal_uid.c hal_ver.c hal_wwdg.c
  group RTTOS/src
    ../RTT/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c slab.c thread.c timer.c
  group RTTOS/cpu
    ../RTT/cortex-m3/: context_rvds.S cpuport.c
    ../RTT/drivers/: board.c
    ../RTT/common/: div0.c backtrace.c
